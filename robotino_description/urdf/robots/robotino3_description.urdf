Commit message: code commenting and clearing the unnecessary files

File: robotino_description/urdf/robots/robotino3_description.urdf (robot description, URDF)
Before this commit: robot robotino, 7 links, 6 joints
Links:
- removed link ir1_link
Joints:
- removed joint ir1_joint
